# Keil uVision project CMSPanel.uvprojx, settings and files
target CMSPanel (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52352_33QFN Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMSPanel +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352, BATTCOUNT=3
  c include: .\User\inc;.\Library\inc;.\CMSIS\Include;.\CMSIS\Core\Include;.\CMSIS;.\Config;.\MDK-ARM;.\GUI
  asm define: USE_HT32_CHIP=4
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./User/: delay.c ht32f5xxxx_01_it.c LinearTabOp.c main.c MCUBeatTimer.c
  group Config
    ./Config/: ht32_board_config.h ht32_op.s HT32F5xxxx_01_DebugSupport.ini ht32f5xxxx_01_usbdconf.h ht32f5xxxx_02_usbdconf.h ht32f5xxxx_conf.h Pindefs.h
  group CMSIS
    ./CMSIS/: system_ht32f5xxxx_01.c
  group MDK_ARM
    ./MDK-ARM/: startup_ht32f5xxxx_01.s
  group Library
    ./Library/src/: ht32f5xxxx_adc.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c ht32_cm0plus_misc.c ht32f5xxxx_bftm.c
  group Hardware
    ./Hardware/: 24Cxx.c I2CDrv.c PMSetup.c LCD_Init.c lcd.c ADC.c IP2366_REG.c Key.c FlashProt.c WatchDog.c PCA9536.c INA226.c PMBUS.c
  group GUI
    ./GUI/: PostScreen.c IncDec.c MenuSystem.c IntEditMenu.c EnterPassWordMenu.c
    ./User/inc/: pic.h lcdfont.h
  group POST
    ./POST/: IP2366_Init.c ScreenDirSet.c InstantCapTest.c SelfTestErrorHandle.c OverChargeDetect.c BalanceMgmt.c HPTypeCGauge.c
  group Menu
    ./Menu/: MainMenu.c ChargePowerMenu.c LVSetMenu.c DischargeMgmtMenu.c SetttingMainMenu.c ChargingSystemMenu.c CapTestMenu.c RestoreFactorySetMenu.c ResetConfigMenu.c DisplayLastCTestMenu.c SetChargeCurrentMenu.c PreChargeCurrentSetMenu.c ChargeVoltSet.c ColumGaugeViewMenu.c ViewChipStateMenu.c EasySetupMenu.c PDOSetMenu.c EnterAdvancedModeMenu.c SystemSecuMenu.c EnterSecuSettingMenu.c AboutMenu.c OTPTempSet.c AdapterEmulationMenu.c TypeCConnReset.c DisplayDirMenu.c EnableInstCapTMenu.c VRechargeMenu.c IStopMenu.c SafetyAlertMenu.c MaxVPDConfigMenu.c ChgPowerWithOutEPR.c LargeMainMenu.c GUIPrefMenu.c BalSysMenu.c ManuStartBalanceMenu.c AutoExtendBalanceMenu.c IstopStdMenu.c
  group EEPROM
    ./EEPROM/: Config.c CapTestMgmt.c LogSystem.c
